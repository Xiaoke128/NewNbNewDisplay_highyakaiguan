# Keil uVision project MianBoardApp.uvprojx, settings and files
target GD32F10X_MD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2GenerationNewNb +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=BinOf@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\User;..\CORE\GD\GD32F10x;..\CORE\GD\GD32F10x\Include;..\Hardware;..\Library\Include;..\CORE;..\Hardware\DS18B20;..\Hw_hal;..\Hardware\ISL1208;..\Hardware\WH_NB73;..\Hardware\MT29F2G01ABAGDWB;..\Hardware\CJ2301
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CORE/GD/GD32F10x/Source/: system_gd32f10x.c
  group Startup
    ../CORE/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Library
    ../Library/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group User
    ./: gd32f10x_it.c main.c systick.c Init.c modbus.c commucateSlave.c protocol.c
  group Hardware
    ../Hardware/DS18B20/: ds18b20.c
    ../Hardware/ISL1208/: Isl1208.c
    ../Hardware/WH_NB73/: wh_nb73.c
    ../Hardware/MT29F2G01ABAGDWB/: MT29F2G01ABAGDWB.c
    ../Hardware/CJ2301/: cj2301.c
  group Hw_hal
    ../Hw_hal/: hw_timer.c hw_uart.c hw_exit.c hw_i2c.c hw_fmc.c hw_wdgt.c hw_spi.c hw_adc.c
target DEBUG (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: as above
  output: 2GenerationNbInterrupt_V1_00L +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
